# Repository hkustenterprize/RM2025-Ethernet-Switch

File README.md:

# RM2025-Ethernet-Switch
https://bbs.robomaster.com/article/760947?source=8

## KiCad design Sentry_MID360_Switcher.kicad_pcb

Parts:
C1, C3, C5, C18, C20, C30, C31, C32, C33, C34, C36, C37, C38, C39, C40, C41, C44, C45, C46, C47, C48, C49, C50, C51, C54, C55, C56, C57: 100n; C_0603_1608Metric
C2, C4, C16, C17: 10u; C_1206_3216Metric
C6, C9, C21: 100p; C_0603_1608Metric
C7, C8, C10, C11, C12, C13, C14, C29, C58, C59: 10u; C_0603_1608Metric
C19: 2u2; C_0603_1608Metric
C22, C23, C24, C26, C27: 22u; C_1206_3216Metric
C25, C35: 20p; C_0603_1608Metric
C42, C43, C52, C53: 1nF 1kV; C_1206_3216Metric
D1: PG; LED_0603_1608Metric
D2: SMAJ17A; D_SMA
D3, D5, D7, D9: G; LED_0603_1608Metric
D4, D6, D8, D10: Y; LED_0603_1608Metric
D11: SMAJ28A; D_SMA
F1: 8A; Fuse_1206_3216Metric
FB1, FB2: 30R 2A; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1, J2: PH2.0_1000M; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal
J3, J4: PH2.0_100M; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal
J5: Conn_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
L1: 2u2; L_Sunlord_MWSA0402S
L2: 4u7; L_Sunlord_MWSA0402S
L3: 15uH; L_Sunlord_MWSA0603S
R1: 8k2; R_0603_1608Metric
R2, R4, R14: 10k; R_0603_1608Metric
R3: 31k6; R_0603_1608Metric
R6: 100k; R_0603_1608Metric
R7: 6k2; R_0603_1608Metric
R8: 2k49; R_0603_1608Metric
R9: NC; R_0603_1608Metric
R10, R11, R12, R13, R16: 2k2; R_0603_1608Metric
R15, R17, R18, R19, R20, R21, R22, R23: 4k7; R_0603_1608Metric
R24, R25, R26, R27, R28, R29, R30, R31: 470R; R_0603_1608Metric
R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43: 75R; R_0603_1608Metric
TR1, TR2, TR3: G2406S; Transformer_Ethernet_YDS_30F-51NL_SO-24_7.1x15.1mm
U1: RTL8367N-VB-CG; QFN-88_10x10_RTL8367N
U2: RY3430; SOT-23-5
U3: RY8411; SOT-23-6
U4: LMR33630ADDA; Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias
Y2: 25Mhz_2016; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+1V1: C6.1, C7.1, C8.1, C10.1, C40.1, C41.1, FB2.1, L1.2, R1.1, U1.41 (DVDDL), U1.60 (DVDDL), U1.64 (DVDDL), U1.76 (NC)
+1V1A: C14.1, C29.1, C33.1, C34.1, C37.1, C38.1, FB2.2, U1.10 (AVDDL), U1.15 (PLLVDDL), U1.20 (AVDDL), U1.30 (AVDDL), U1.38 (AVDDL), U1.47 (AVDDL), U1.53 (AVDDL), U1.88 (AVDDL)
+3V3: C9.1, C11.1, C12.1, C13.1, C39.1, C58.1, C59.1, FB1.1, L2.2, R3.1, R10.2, R11.1, R14.1, R16.2, U1.63 (DVDDIO), U2.1 (EN), U2.4 (VIN)
+3V3A: C1.1, C3.1, C30.1, C31.1, C32.1, FB1.2, U1.5 (AVDDH), U1.25 (AVDDH), U1.35 (AVDDH), U1.40 (AVDDH), U1.42 (AVDDH), U1.52 (AVDDH), U1.77 (AVDDH), U1.83 (AVDDH)
+24V: C2.1, C4.1, C16.1, C17.1, C18.1, D11.1 (A1), F1.2, U3.4 (EN), U3.5 (IN), U4.2 (VIN), U4.3 (EN)
/OSC_IN: C25.1, U1.79 (XTALI), Y2.1
/OSC_OUT: C35.1, U1.78 (XTALO), Y2.3
/P0LED0: R23.1, R24.1, U1.75 (GP_O52/P0LED0/LED_CK/SMI_SEL)
/P0LED1: R22.1, R25.1, U1.74 (GPIO51/P0LED1/LED_DA)
/P0MDIAN: TR1.11 (TD4+), U1.85 (P0MDIAN)
/P0MDIAP: TR1.12 (TD4-), U1.84 (P0MDIAP)
/P0MDIBN: TR1.8 (TD3+), U1.87 (P0MDIBN)
/P0MDIBP: TR1.9 (TD3-), U1.86 (P0MDIBP)
/P0MDICN: TR1.5 (TD2+), U1.2 (P0MDICN)
/P0MDICP: TR1.6 (TD2-), U1.1 (P0MDICP)
/P0MDIDN: TR1.2 (TD1+), U1.4 (P0MDIDN)
/P0MDIDP: TR1.3 (TD1-), U1.3 (P0MDIDP)
/P0_AN: J1.2, TR1.14 (MX4+)
/P0_AP: J1.1, TR1.13 (MX4-)
/P0_BN: J1.6, TR1.17 (MX3+)
/P0_BP: J1.3, TR1.16 (MX3-)
/P0_CN: J1.5, TR1.20 (MX2+)
/P0_CP: J1.4, TR1.19 (MX2-)
/P0_DN: J1.8, TR1.23 (MX1+)
/P0_DP: J1.7, TR1.22 (MX1-)
/P1LED0: R20.1, R26.1, U1.72 (GP_O48/P1LED0/RESERVED)
/P1LED1: R21.1, R27.1, U1.73 (GPIO49/P1LED1)
/P1MDIAN: TR2.11 (TD4+), U1.7 (P1MDIAN)
/P1MDIAP: TR2.12 (TD4-), U1.6 (P1MDIAP)
/P1MDIBN: TR2.8 (TD3+), U1.9 (P1MDIBN)
/P1MDIBP: TR2.9 (TD3-), U1.8 (P1MDIBP)
/P1MDICN: TR2.5 (TD2+), U1.12 (P1MDICN)
/P1MDICP: TR2.6 (TD2-), U1.11 (P1MDICP)
/P1MDIDN: TR2.2 (TD1+), U1.14 (P1MDIDN)
/P1MDIDP: TR2.3 (TD1-), U1.13 (P1MDIDP)
/P1_AN: J2.2, TR2.14 (MX4+)
/P1_AP: J2.1, TR2.13 (MX4-)
/P1_BN: J2.6, TR2.17 (MX3+)
/P1_BP: J2.3, TR2.16 (MX3-)
/P1_CN: J2.5, TR2.20 (MX2+)
/P1_CP: J2.4, TR2.19 (MX2-)
/P1_DN: J2.8, TR2.23 (MX1+)
/P1_DP: J2.7, TR2.22 (MX1-)
/P2MDIAN: U1.17 (P2MDIAN)
/P2MDIAP: U1.16 (P2MDIAP)
/P2MDIBN: U1.19 (P2MDIBN)
/P2MDIBP: U1.18 (P2MDIBP)
/P3LED0: R15.1, R30.1, U1.68 (GP_O43/P3LED0/EN_SPIF)
/P3LED1: R17.1, R31.1, U1.67 (GPIO41/P3LED1)
/P3MDIAN: TR3.11 (TD4+), U1.27 (P3MDIAN)
/P3MDIAP: TR3.12 (TD4-), U1.26 (P3MDIAP)
/P3MDIBN: TR3.8 (TD3+), U1.29 (P3MDIBN)
/P3MDIBP: TR3.9 (TD3-), U1.28 (P3MDIBP)
/P3_RX+: J3.8, TR3.16 (MX3-)
/P3_RX-: J3.7, TR3.17 (MX3+)
/P3_TX+: J3.6, TR3.13 (MX4-)
/P3_TX-: J3.3, TR3.14 (MX4+)
/P4LED0: R18.1, R28.1, U1.65 (GP_O39/P4LED0/EEPROM_MOD)
/P4LED1: R19.1, R29.1, U1.66 (GPIO40/P4LED1)
/P4MDIAN: TR3.5 (TD2+), U1.44 (P4MDIAN)
/P4MDIAP: TR3.6 (TD2-), U1.43 (P4MDIAP)
/P4MDIBN: TR3.2 (TD1+), U1.46 (P4MDIBN)
/P4MDIBP: TR3.3 (TD1-), U1.45 (P4MDIBP)
/P4_RX+: J4.8, TR3.22 (MX1-)
/P4_RX-: J4.7, TR3.23 (MX1+)
/P4_TX+: J4.6, TR3.19 (MX2-)
/P4_TX-: J4.3, TR3.20 (MX2+)
/PG: D1.2 (A), R11.2, U4.4 (PG)
/VCC1: C19.1, U4.6 (VCC)
/nRESET: C36.1, R14.2, U1.80 (nRESET)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.2, C53.1, C54.1, C55.1, C56.1, C57.1, C58.2, C59.2, D1.1 (K), D2.2 (A2), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.2 (A2), H1.1, H2.1, H3.1, H4.1, J3.1, J3.2, J4.1, J4.2, J5.1, R2.2, R4.2, R7.2, R8.2, R9.2, R12.2, R13.2, R15.2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
unnamed: C42.1, R32.2, R33.2, R34.2, R35.2
unnamed: C43.1, R36.2, R37.2, R38.2, R39.2
unnamed: C44.2, TR1.1 (CT)
unnamed: C45.2, TR1.4 (CT)
unnamed: C46.2, TR1.7 (CT)
unnamed: C47.2, TR1.10 (CT)
unnamed: C48.2, TR2.1 (CT)
unnamed: C49.2, TR2.4 (CT)
unnamed: C50.2, TR2.7 (CT)
unnamed: C51.2, TR2.10 (CT)
unnamed: C52.1, R40.2, R41.2
unnamed: C53.2, R42.2, R43.2
unnamed: C54.2, TR3.1 (CT)
unnamed: C55.2, TR3.4 (CT)
unnamed: C56.2, TR3.7 (CT)
unnamed: C57.2, TR3.10 (CT)
unnamed: D3.2 (A), R24.2
unnamed: D4.2 (A), R25.2
unnamed: D5.2 (A), R26.2
unnamed: D6.2 (A), R27.2
unnamed: D7.2 (A), R28.2
unnamed: D8.2 (A), R29.2
unnamed: D9.2 (A), R30.2
unnamed: D10.2 (A), R31.2
unnamed: F1.1, J5.2
unnamed: R12.1, U1.61 (RESERVED)
unnamed: R13.1, U1.62 (RESERVED)
unnamed: R32.1, TR1.24 (CT)
unnamed: R33.1, TR1.21 (CT)
unnamed: R34.1, TR1.18 (CT)
unnamed: R35.1, TR1.15 (CT)
unnamed: R36.1, TR2.24 (CT)
unnamed: R37.1, TR2.21 (CT)
unnamed: R38.1, TR2.18 (CT)
unnamed: R39.1, TR2.15 (CT)
unnamed: R40.1, TR3.18 (CT)
unnamed: R41.1, TR3.15 (CT)
unnamed: R42.1, TR3.21 (CT)
unnamed: R43.1, TR3.24 (CT)
unnamed: R16.1, U1.69 (GP_O44/DIS_8051)
unnamed: R8.1, U1.37 (MDIREF)
unnamed: R9.1, R10.1, U1.81 (SCK/EN_EEE)
unnamed: C6.2, R1.2, R2.1, U2.5 (FB)
unnamed: L1.1, U2.3 (SW)
unnamed: C5.1, U3.1 (BS)
unnamed: C9.2, R3.2, R4.1, U3.3 (FB)
unnamed: C5.2, L2.1, U3.6 (LX)
unnamed: C20.1, U4.7 (BOOT)
unnamed: C21.2, R6.2, R7.1, U4.5 (FB)
unnamed: C20.2, L3.1, U4.8 (SW)
VOUT1: C21.1, C22.1, C23.1, C24.1, C26.1, C27.1, D2.1 (A1), J3.4, J3.5, J4.4, J4.5, L3.2, R6.1

Notes on the sheet:
1-白橙 2-橙 3-白绿 4-蓝 5-蓝白 6-绿 7-白棕 8-棕

Board: 4 copper layers, 45.0 x 60.0 mm, 133 parts (82 on the bottom side), 118 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C18, C20, C3, C30, C31, C32, C33, C34, C36, C37, C38, C39, C40, C41, C44, C45, C46, C47, C48, C49, C5, C50, C51, C54, C55, C56, C57",0603,28,100n,
"C10, C11, C12, C13, C14, C29, C58, C59, C7, C8",0603,10,10u,
"C16, C17, C2, C4",1206,4,10u,
C19,0603,1,2u2,
"C21, C6, C9",0603,3,100p,
"C22, C23, C24, C26, C27",1206,5,22u,
"C25, C35",0603,2,20p,
"C42, C43, C52, C53",1206,4,1nF 1kV,
D1,0603,1,PG,
"D10, D4, D6, D8",0603,4,Y,
D11,D_SMA,1,SMAJ28A,
D2,D_SMA,1,SMAJ17A,
"D3, D5, D7, D9",0603,4,G,
F1,1206,1,8A,
"FB1, FB2",0603,2,30R 2A,
"J1, J2",JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal,2,PH2.0_1000M,
"J3, J4",JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal,2,PH2.0_100M,
J5,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,Conn_01x02,
L1,L_Sunlord_MWSA0402S,1,2u2,
L2,L_Sunlord_MWSA0402S,1,4u7,
L3,L_Sunlord_MWSA0603S,1,15uH,
R1,0603,1,8k2,
"R10, R11, R12, R13, R16",0603,5,2k2,
"R14, R2, R4",0603,3,10k,
"R15, R17, R18, R19, R20, R21, R22, R23",0603,8,4k7,
"R24, R25, R26, R27, R28, R29, R30, R31",0603,8,470R,
R3,0603,1,31k6,
"R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43",0603,12,75R,
R6,0603,1,100k,
R7,0603,1,6k2,
R8,0603,1,2k49,
R9,0603,1,NC,
"TR1, TR2, TR3",Transformer_Ethernet_YDS_30F-51NL_SO-24_7.1x15.1mm,3,G2406S,
U1,QFN-88_10x10_RTL8367N,1,RTL8367N-VB-CG,
U2,SOT-23-5,1,RY3430,
U3,SOT-23-6,1,RY8411,
U4,Texas_HSOP-8-1EP_3.9x4.9mm_P1.27mm_ThermalVias,1,LMR33630ADDA,
Y2,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,25Mhz_2016,

## Commit log

2025-07-31 PCB File
2025-07-31 生产文件
